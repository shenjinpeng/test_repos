# Keil uVision project RtdDseries.uvproj, settings and files
target RTD2482RD_Demo_Board (MCS-51)
  device: W78LE516 Winbond
  cpu: IRAM(0 - 0xFF) XRAM(0- 0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: RTD2482RD_Demo_Board +hex
  AfterMake: Bin\2472RD_Demo.cmd
  c flags: Optimize=9 SizeSpeed=1
  c define: _PROJECT = _RTD2472RD_DEMO_BOARD
  link misc: ;BANK0(?CO?Realtek_EEPROM(0x3000),?CO?ADJUST,?CO?HDMI,?CO?REALTEK_KEY,?CO?DISPLAYPORT)
BANK0(?CO?MAIN(0x3000),?CO?Realtek_EEPROM,?CO?YPBPR,?CO?REALTEK_KEY)
BANK1(?CO?ADJUST(0x3000),?CO?DISPLAYPORT,?CO?FRAMESYNC,?CO?HDMI)
BANK2(?CO?Realtek_OSD(0x3000),?CO?Realtek_OSDTABLE,?CO?REALTEK_RESERVED(0xC000))
  group Project
    ./Project/: Project.h RTD2482RD_Demo_Board.h RTD2545LR_Demo_Board.h RTD2482D_Demo_Board.h
  group Pcb
    ./Pcb/: RTD2482RD_Demo_PCB.h RTD2545LR_DEMO_PCB.h RTD2482D_Demo_PCB.h
  group Options
    ./MainDef/: Version.h AdvanceDef.h
    ./Common/Header/: Include.h
  group Panel
    ./Panel/: 00_CMO_LVDS_17.h 01_AU_RSDS_17.h 02_AU_LVDS_15.h 03_AU_LVDS_20_WSXGA.h 04_AU_LVDS_20_UXGA.h 05_SAMSUNG_LVDS_19_WXGA.h 06_CMO_LVDS_20_SXGA_PLUS.h 07_CMO_LVDS_19_WXGA.h 08_CMO_LVDS_22_WSXGA_PLUS.h 09_AU_LVDS_22_WSXGA.h 10_AU_LVDS_23_WUXGA.h 11_AU_LVDS_21_5_WUXGA.h 12_AU_LVDS_24_WUXGA.h
  group DCR
    ./DCR/Code/: DCR_Type_1.c DCR_Type_2.c DCR_Type_3.c
  group Common
    ./Common/Code/: Align.c Ddc.c Debug.c I2c.c Int.c Main.c Mcu.c Timer.c Uart.c
    ./Common/: STARTUP.A51 L51_bank.a51
  group Scaler
    ./Scaler/Code/: Adjust.c Auto.c DisplayPort.c FrameSync.c Hdmi.c Memory.c Misc.c Mode.c Power.c Scaler.c Source.c Sync.c Video.c YPbPr.c
  group Realtek OSD
    ./User/Realtek OSD/Code/: Realtek_BankSwitch.c Realtek_Ddc.c Realtek_Eeprom.c Realtek_Flash.c Realtek_Key.c Realtek_Osd.c Realtek_OsdDisp.c Realtek_OsdFunc.c Realtek_OsdTable.c Realtek_Struct.c Realtek_Reserved.c
    ./User/Realtek OSD/Header/: Realtek_Define.h
target RTD2482D_Demo_Board (MCS-51)
  device: W78LE516 Winbond
  cpu: IRAM(0 - 0xFF) XRAM(0- 0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: RTD2482D_Demo_Board +hex
  AfterMake: Bin\2472D_Demo.cmd
  c flags: Optimize=9 SizeSpeed=1
  c define: _PROJECT = _RTD2472D_DEMO_BOARD
  link misc: ;BANK0(?CO?Realtek_EEPROM(0x3000),?CO?ADJUST,?CO?HDMI,?CO?REALTEK_KEY,?CO?DISPLAYPORT)
BANK0(?CO?MAIN(0x3000),?CO?Realtek_EEPROM,?CO?YPBPR,?CO?REALTEK_KEY)
BANK1(?CO?ADJUST(0x3000),?CO?FRAMESYNC,?CO?HDMI)
BANK2(?CO?Realtek_OSD(0x3000),?CO?Realtek_OSDTABLE,?CO?REALTEK_RESERVED(0xC000))
